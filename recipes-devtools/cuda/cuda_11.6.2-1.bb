RDEPENDS:${PN} = "cuda-toolkit cuda-demo-suite cuda-cudart"